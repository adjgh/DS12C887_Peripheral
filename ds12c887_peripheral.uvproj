# Keil uVision project ds12c887_peripheral.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC89C52RC STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: ds12c887_peripheral (library)
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: pr_write.c pr_read.c settime.c gettime.c islowpower.c alarm_enable.c alarm_disable.c init.c bcd.c bcd2dec.c sqw_output.c sqw_output_noirq.c SETTIME_EX.c today.c setalarm.c
